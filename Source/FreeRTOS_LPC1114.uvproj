# Keil uVision project FreeRTOS_LPC1114.uvproj, settings and files
target FreeRTOS_LPC1114 (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Reader_LPC1114 +hex
  c flags: Optim=1
  c include: .\.;.\platform\lpc11xx;.\platform\cmmis;.\FreeRTOS_Source\include;.\FreeRTOS_Source;.\Common_Demo_Tasks;.\FreeRTOS_Source\portable\RVDS\ARM_CM0;.\Common_Demo_Tasks;.\Common_Demo_Tasks\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group platform
    ./platform/lpc11xx/: LPC11xx.h startup_LPC11xx.s system_LPC11xx.c system_LPC11xx.h
  group cmsis
    ./platform/cmmis/: core_cm0.h core_cmFunc.h core_cmInstr.h
  group FreeRTOS
    ./FreeRTOS_Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS_Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./: FreeRTOSConfig.h IntQueueTimer.c IntQueueTimer.h main-blinky.c main.c
    ./FreeRTOS_Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ./FreeRTOS_Source/portable/MemMang/: heap_4.c
  group Common_Demo_Tasks
    ./Common_Demo_Tasks/: blocktim.c countsem.c IntQueue.c recmutex.c
    ./Common_Demo_Tasks/include/: blocktim.h countsem.h IntQueue.h recmutex.h
